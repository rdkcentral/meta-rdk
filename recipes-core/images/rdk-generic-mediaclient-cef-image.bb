require rdk-generic-mediaclient-image.bb

IMAGE_INSTALL += "packagegroup-chromium-eglfs"

