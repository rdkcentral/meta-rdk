require rdk-generic-hybrid-image.bb

IMAGE_INSTALL += "packagegroup-chromium-eglfs"
