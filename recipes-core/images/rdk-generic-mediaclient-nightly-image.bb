SUMMARY = "RDK mediaclient nightly Image"
require rdk-generic-mediaclient-image.bb
IMAGE_FEATURES += "nightly"

