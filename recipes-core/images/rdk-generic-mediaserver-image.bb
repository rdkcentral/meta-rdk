SUMMARY = "RDK Mediaserver Image"

IMAGE_FEATURES += "mediaserver"

require  rdk-generic-media-common.inc

