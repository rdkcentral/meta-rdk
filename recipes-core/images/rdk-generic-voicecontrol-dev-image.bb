SUMMARY = "A console-only image for the RDK-X yocto build with development tools"

require recipes-core/images/rdk-generic-voicecontrol-image.bb
