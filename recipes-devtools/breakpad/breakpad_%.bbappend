FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://test-HE.sh \
           "
