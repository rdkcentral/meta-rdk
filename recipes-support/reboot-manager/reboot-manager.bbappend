SRC_URI:append = "${CMF_GITHUB_ROOT}/reboot-manager;${CMF_GITHUB_SRC_URI_SUFFIX};name=reboot-manager"

SRCREV_FORMAT = "reboot-manager"

